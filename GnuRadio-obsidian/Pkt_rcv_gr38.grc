options:
  parameters:
    author: Barry Duggan
    description: packet receive (for GNURadio 3.8)
    generate_options: qt_gui
    id: pkt_rcv_gr38
    output_language: python
    title: pkt_rcv_gr38
  states: {}

blocks:
- name: bandwith
  id: variable
  parameters:
    value: '0'
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: centr_freq
  id: variable
  parameters:
    value: 433.2e6
  states: {}
- name: cutt
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: 1e3
    stop: 200e3
    value: 75e3
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '125'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_crc
    value: digital.header_format_crc(len_key, num_key)
  states: {}
- name: len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: num_key
  id: variable
  parameters:
    value: '"packet_num"'
  states: {}
- name: order
  id: variable
  parameters:
    value: '2'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 768e3
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: bpsk
    modulus: sps
    step_size: '.0001'
    type: cma
  states: {}
- name: width
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: 1e3
    stop: 150e3
    value: 25e3
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/leonid/Рабочий стол/priem_blya_CRC.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/leonid/Рабочий стол/priem_blya_CRCcewfwefasdfasdf.txt
    type: byte
  states: {state: disabled}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: order
    w: phase_bw
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '1'
    training_sequence: '[]'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: '1'
    gain: '1'
    samp_rate: 1e6
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: ((usrp_rate/samp_rate)*rs_ratio)
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      The LMS DD equalizer has been
      replaced by a Linear Equalizer
      and an Adaptive Algorithm (CMA) for
      version 3.9
    note: LMS equalizer replaced
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 433.22e6
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '96'
    type: ccc
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'False '
    bandwidth: '5500'
    center_freq: 433.2e6
    gain: '40'
    samp_rate: 1e6
    type: fc32
    vga: '40'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rx2
  states: {}

connections:
- [blocks_repack_bits_bb_1, '0', digital_crc32_bb_1, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_1, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc32_bb_1, '0', blocks_file_sink_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_time_sink_x_0, '0']
- [digital_map_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [mmse_resampler_xx_0, '0', blocks_throttle2_0, '0']
- [rational_resampler_xxx_0, '0', mmse_resampler_xx_0, '0']
- [soapy_hackrf_source_0, '0', low_pass_filter_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_1, '0', digital_diff_decoder_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
